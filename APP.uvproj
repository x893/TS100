# Keil uVision project APP.uvproj, settings and files
target APP (5060422::V5.06 update 4 (build 422)::ARMCC)
  device: STM32F103TB STMicroelectronics
  cpu: IRAM(0x20000000-0x20004FFF) IROM(0x8000000-0x801FFFF) CLOCK(8000000) CPUTYPE("Cortex-M3")
  output: APP
  AfterMake: fromelf --bin --output=build\APP.bin build\APP.axf
  c flags: Optim=4 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=2
  c define: USE_STDPERIPH_DRIVER STM32F10X_MD TYPE_S100
  c include: .\Inc;.\Src;.\Libraries\CMSIS\Include;.\Libraries\CMSIS\Device\STM32F10x\Include;.\Libraries\STM32F10x_StdPeriph_Driver\inc;.\Libraries\STM32_USB-FS-Device_Driver\inc
  library: MicroLIB
  memory RVCT4: ROM 0x8004000 size 0x8000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group Src
    ./src/: startup_stm32f10x_md.s
    ./Src/: STM32F103_System.c Main.c Bios.c CTRL.c Disk.c Flash.c HARDWARE.c I2C.c MMA8652FC.c Oled.c UI.c own_sprintf.c
  group StdPeriph_Driver
    ./Libraries/STM32F10x_StdPeriph_Driver/src/: misc.c stm32f10x_adc.c stm32f10x_bkp.c stm32f10x_can.c stm32f10x_crc.c stm32f10x_dbgmcu.c stm32f10x_dma.c stm32f10x_exti.c stm32f10x_flash.c stm32f10x_gpio.c stm32f10x_i2c.c stm32f10x_iwdg.c stm32f10x_pwr.c stm32f10x_rcc.c stm32f10x_spi.c stm32f10x_tim.c stm32f10x_wwdg.c
  group MSD
    ./Src/: USB_bot.c USB_desc.c USB_istr.c USB_prop.c USB_pwr.c USB_scsi.c
  group USB-FS-Devier
    ./Libraries/STM32_USB-FS-Device_Driver/src/: usb_core.c usb_init.c usb_int.c usb_mem.c usb_regs.c usb_sil.c
